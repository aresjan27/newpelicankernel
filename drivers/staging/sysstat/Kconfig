## drivers/staging/sysstat/Kconfig
```kconfig
config SYS_STAT
	tristate "kernel stat thread"
	depends on STAGING
	default m
	---help---
```
